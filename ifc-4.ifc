Properties of the parts of a building model (IFC4)

# File
Description: IP-65 Deckelset, für Differenzdruckschalter JDL, ViewDefinition[CoordinationView]
File name: ifc-4.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: H531012, IP-65 Deckelset, für Differenzdruckschalter JDL
In: Raum
Description: IP-65 Deckelset für Differenzdruckschalter JDL. Bestehend aus Deckel mit Druckausgleichselement, O-Ring und 3 Schrauben.; Classification: EC011650 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: H531012; ModelLabel: JZ-28; GlobalTradeItemNumber: 4050528065964; ProductURL: https://alre.de/produkt_H531012
Pset_Specification - NominalLength: 0.0736 m; NominalWidth: 0.0736 m; NominalDepth: 0.03 m; NetWeight: 0.039
Pset_ALRE_ETIM_Properties - Art des Zubehörs/Ersatzteils: sonstige; Zubehör: yes; ETIM-Klasse: EC011650; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-H531012.pdf
